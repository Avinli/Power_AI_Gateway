# Keil uVision project BLE_Ota.uvprojx, settings and files
target Production (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: BLE_Ota +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32WB55xx,USE_HAL_DRIVER,CORE_CM4
  c misc: --diag_suppress 111
  c include: ../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../Drivers/CMSIS/Include;../../../Middlewares/STM32_WPAN/ble/core/template;../../../Middlewares/ST/STM32_WPAN/ble/core/auto;../../../Middlewares/STM32_WPAN;../../../Middlewares/STM32_WPAN/ble/core/Inc;../../../Middlewares/STM32_WPAN/ble/core/;../../../Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl;../../../Middlewares/STM32_WPAN/utilities;../../../Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci;../../../Utilities/lpm/tiny_lpm;../../../Utilities/sequencer;../../../Middlewares/STM32_WPAN/interface/patterns/ble_thread;../../../Middlewares/STM32_WPAN/ble;../Core/Inc;../STM32_WPAN/app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\stm32wb55xx_flash_cm4.sct
  group Application/Core
    ../Core/Src/: app_entry.c stm32_lpm_if.c hw_timerserver.c hw_uart.c main.c stm32wbxx_it.c app_debug.c
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/STM32_WPAN/app
    ../STM32_WPAN/App/: app_ble.c otas_app.c
  group Application/STM32_WPAN/target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../../../: readme.txt
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/STM32_WPAN/ble/blesvc
    ../../../Middlewares/STM32_WPAN/ble/svc/Src/: otas_stm.c svc_ctl.c
  group Middlewares/STM32_WPAN/ble/core
    ../../../Middlewares/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c
    ../../../Middlewares/STM32_WPAN/ble/core/template/: osal.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c shci_tl.c hci_tl_if.c shci_tl_if.c tl_mbox.c
  group Middlewares/STM32_WPAN/utilities
    ../../../Middlewares/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
  group Utilities
    ../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../Utilities/sequencer/: stm32_seq.c
software components: CMSIS:CORE 5.2.0
